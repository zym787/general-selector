# Keil uVision project XZF.uvprojx, settings and files
target XZF_VALVE (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XZF +hex
  AfterMake: keil-build-viewer.exe -NOPATH
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SRC\APP;..\SRC\SYSTEM\timer;..\SRC\SYSTEM\delay;..\SRC\SYSTEM\sys;..\SRC\SYSTEM\usart;..\SRC\CoreSupport;..\SRC\HARDWARE\usinterface;..\SRC\HARDWARE\stmFlash;..\SRC\HARDWARE\motor;..\SRC\HARDWARE\valve;..\SRC\HARDWARE\EEPROM;..\SRC\HARDWARE\ags_mb;..\SRC\HARDWARE\protExt;..\SRC\HARDWARE\signal;..\SRC\HARDWARE\io;..\SRC\SYSTEM\adc;..\SRC\CoreSupport\STM32F10x_StdPeriph_Driver\inc;..\SRC\3rd\common;..\SRC\3rd\xfusion\xf_common;..\SRC\3rd\xfusion\xf_utils_log;..\SRC\3rd\xfusion
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../SRC/APP/: startup_stm32f10x_md.s
  group APP
    ../SRC/APP/: main.c
  group HARDWARE
    ../SRC/HARDWARE/valve/: valve.c
    ../SRC/HARDWARE/EEPROM/: EEP24Serial.c
    ../SRC/HARDWARE/usinterface/: usFunc.c USINTF_CR-0.lib
    ../SRC/HARDWARE/motor/: Smotor.lib
    ../SRC/HARDWARE/ags_mb/: ags_mb.c ModBusCrc16.c
    ../SRC/HARDWARE/protExt/: protExt.c
    ../SRC/HARDWARE/signal/: signal.c
    ../SRC/HARDWARE/io/: bsp_io.c
  group SYSTEM
    ../SRC/SYSTEM/delay/: delay.c
    ../SRC/SYSTEM/sys/: sys.c
    ../SRC/SYSTEM/usart/: usart.c
    ../SRC/SYSTEM/timer/: timer.c
    ../SRC/SYSTEM/adc/: adc.c
  group StdPeriph_Driver
    ../SRC/CoreSupport/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c
    ../SRC/CoreSupport/: stm32f10x_conf.h
  group Doc
    ../Doc/: XZF_v2.0.0修改说明.md
  group 3rd/xfusion
    ../SRC/3rd/xfusion/xf_utils_log/: xf_utils_log_dump.c
  group elab/common
    ../SRC/3rd/common/: elab_log.c elab_common.c
